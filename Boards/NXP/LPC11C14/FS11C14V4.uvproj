# Keil uVision project FS11C14V4.uvproj, settings and files
target FS11C14V4-UCOSII (ARM-ADS)
  device: LPC11C14x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: FS11C14V4 +hex
  c flags: Optim=1
  c include: ..\..\..\uCOS-II\Source
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group System
    ./: startup_LPC11xx.s
  group Ucosii
    ../../../uCOS-II/Source/: os_tmr.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c ucos_ii.h
  group Ucosii-port
    ../../../uCOS-II/Ports/ARM-Cortex-M0/LPC11C14/GNU/: os_dbg.c os_cpu.h os_cpu_a.asm os_cpu_c.c
